v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {comparator_2stage.sym} 210 -160 0 0 {name=x1}
C {title.sym} 60 -30 0 0 {name=l1 author="Luc Bastien"}
C {lab_pin.sym} 60 -190 0 0 {name=p1 sig_type=std_logic lab=VIN2}
C {lab_pin.sym} 60 -170 0 0 {name=p2 sig_type=std_logic lab=VIN1}
C {lab_pin.sym} 60 -150 0 0 {name=p3 sig_type=std_logic lab=CK}
C {lab_pin.sym} 360 -190 2 0 {name=p4 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 360 -170 2 0 {name=p5 sig_type=std_logic lab=VOUT2}
C {lab_pin.sym} 360 -150 2 0 {name=p6 sig_type=std_logic lab=VOUT1}
C {gnd.sym} 360 -130 0 0 {name=l2 lab=0}
