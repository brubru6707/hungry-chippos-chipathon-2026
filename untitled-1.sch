v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {comparator_alt/schematic/comparator_2stage.sym} 290 -130 0 0 {name=x1}
C {ipin.sym} 140 -160 0 0 {name=p1 lab=CKL}
C {ipin.sym} 140 -140 0 0 {name=p2 lab=VIN2}
C {ipin.sym} 140 -120 0 0 {name=p3 lab=VIN1}
C {ipin.sym} 140 -100 0 0 {name=p4 lab=CK}
C {opin.sym} 440 -140 0 0 {name=p5 lab=VOUT2}
C {opin.sym} 440 -120 0 0 {name=p6 lab=VOUT1}
C {gnd.sym} 440 -100 0 0 {name=l1 lab=0}
C {vdd.sym} 440 -160 0 0 {name=l2 lab=VDD}
C {code_shown.sym} 530 -370 0 0 {name=s1 only_toplevel=false value="*Outputs purposely crossed to match polarity with rest of ADC"}
