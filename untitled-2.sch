v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {comparator_alt/schematic/inv_slow.sym} 130 -40 0 0 {name=x1}
