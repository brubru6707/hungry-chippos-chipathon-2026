** sch_path: designs/untitled.sch
**.subckt untitled
V1 VIN 0 PULSE(0 1 0.5n 100p 100p 1n 2n)
R1 VOUT VIN 1k m=1
C1 VOUT 0 1p m=1
**.ends
.end
